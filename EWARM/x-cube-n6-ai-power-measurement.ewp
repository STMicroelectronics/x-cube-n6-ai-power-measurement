# IAR project x-cube-n6-ai-power-measurement.ewp, settings and files
configuration STM32N657xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM; USE_IMX335_SENSOR; STM32N6570_DK_REV=STM32N6570_DK_C01; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_USER_IMPL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; LL_ATON_SW_FALLBACK
  ICCARM.CCIncludePath2: ..\Inc; ..\Lib\lib_vision_models_pp\lib_vision_models_pp\Inc; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy; ..\STM32Cube_FW_N6\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\DSP\Include; ..\STM32Cube_FW_N6\Drivers\BSP\Components\Common; ..\STM32Cube_FW_N6\Drivers\BSP\STM32N6570-DK; ..\Lib\Camera_Middleware\ISP_Library\isp\Inc; ..\Lib\Camera_Middleware\ISP_Library\evision\Inc; ..\Lib\AI_Runtime\Inc; ..\Lib\AI_Runtime\Npu\ll_aton; ..\Lib\AI_Runtime\Npu\Devices\STM32N6XX; ..\STM32Cube_FW_N6\Utilities\lcd; ..\STM32Cube_FW_N6\Drivers\BSP\Components\aps256xx; ..\Lib\Camera_Middleware\sensors; ..\Lib\Camera_Middleware\sensors\imx335; ..\Lib\Camera_Middleware\sensors\vd6g; ..\Lib\Camera_Middleware\sensors\vd55g1; ..\Lib\Camera_Middleware; ..\Lib\ai-postprocessing-wrapper
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: x-cube-n6-ai-power-measurement.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: app_cam.c app_fuseprogramming.c main.c mcu_cache.c npu_cache.c pwr_timestamp.c stm32_lcd_ex.c stm32n6xx_it.c system_clock.c
    ../Model/: network.c
    ../Lib/AI_Runtime/Lib/ABI2.1/ARMCortexM55/: NetworkRuntime1020_CM55_IAR.a
    ../Lib/lib_vision_models_pp/lib_vision_models_pp/Src/: od_pp_centernet.c od_pp_ssd.c od_pp_ssd_st.c od_pp_yolov2.c od_pp_yolov5.c od_pp_yolov8.c vision_models_pp.c vision_models_pp_maxi_if32.c vision_models_pp_maxi_is8.c vision_models_pp_maxi_iu8.c
  group Drivers/BSP/Components
    ../STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/BSP/STM32N6570-DK
    ../STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_xspi.c
  group Drivers/CMSIS
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group ll_aton
    ../Lib/AI_Runtime/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Middlewares/ai-postprocessing-wrapper
    ../Lib/ai-postprocessing-wrapper/: app_postprocess_iseg_yolo_v8_ui.c app_postprocess_mpe_pd_uf.c app_postprocess_mpe_yolo_v8_uf.c app_postprocess_od_st_ssd_uf.c app_postprocess_od_st_yolox_uf.c app_postprocess_od_yolov2_uf.c app_postprocess_od_yolov5_uu.c app_postprocess_od_yolov8_uf.c app_postprocess_od_yolov8_ui.c app_postprocess_spe_movenet_uf.c app_postprocess_sseg_deeplab_v3_uf.c
  group Middlewares/Camera_Middleware
    ../Lib/Camera_Middleware/: cmw_camera.c cmw_utils.c
  group Middlewares/Camera_Middleware/sensors
    ../Lib/Camera_Middleware/sensors/: cmw_imx335.c cmw_vd55g1.c cmw_vd66gy.c
  group Middlewares/Camera_Middleware/sensors/Drivers
    ../Lib/Camera_Middleware/sensors/imx335/: imx335.c imx335_reg.c
    ../Lib/Camera_Middleware/sensors/vd55g1/: vd55g1.c
    ../Lib/Camera_Middleware/sensors/vd6g/: vd6g.c
  group Middlewares/ISP_Library
    ../Lib/Camera_Middleware/ISP_Library/isp/Src/: isp_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
    ../Lib/Camera_Middleware/ISP_Library/evision/Lib/: libn6-evision-awb_iar.a libn6-evision-st-ae_iar.a
  group Utilities/lcd
    ../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
